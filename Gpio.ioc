# file: Gpio.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F429Z(E-G-I)Tx
Mcu.Package=LQFP144
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PH0/OSC_IN.Mode=HSE-External-Oscillator
PH0/OSC_IN.Signal=RCC_OSC_IN
PH1/OSC_OUT.Mode=HSE-External-Oscillator
PH1/OSC_OUT.Signal=RCC_OSC_OUT
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=SW4STM32
RCC.48MHZClocksFreq_Value=90000000
RCC.AHBFreq_Value=180000000
RCC.APB1CLKDivider=RCC_HCLK_DIV4
RCC.APB1Freq_Value=45000000
RCC.APB1TimFreq_Value=90000000
RCC.APB2CLKDivider=RCC_HCLK_DIV2
RCC.APB2Freq_Value=90000000
RCC.APB2TimFreq_Value=180000000
RCC.CortexFreq_Value=180000000
RCC.HCLKFreq_Value=180000000
RCC.HSE_VALUE=8000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.PLLM=8
RCC.PLLN=360
RCC.PLLSourceVirtual=RCC_PLLSOURCE_HSE
RCC.SYSCLKFreq_VALUE=180000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
RCC.VCOOutputFreq_Value=360000000
board=Gpio

// file: Src/main.c
/**
  ******************************************************************************
  * File Name          : main.c
  * Description        : Main program body
  ******************************************************************************
  ** This notice applies to any and all portions of this file
  * that are not between comment pairs USER CODE BEGIN and
  * USER CODE END. Other portions of this file, whether
  * inserted by the user or by software development tools
  * are owned by their respective copyright owners.
  *
  * COPYRIGHT(c) 2017 STMicroelectronics
  *
  * Redistribution and use in source and binary forms, with or without modification,
  * are permitted provided that the following conditions are met:
  *   1. Redistributions of source code must retain the above copyright notice,
  *      this list of conditions and the following disclaimer.
  *   2. Redistributions in binary form must reproduce the above copyright notice,
  *      this list of conditions and the following disclaimer in the documentation
  *      and/or other materials provided with the distribution.
  *   3. Neither the name of STMicroelectronics nor the names of its contributors
  *      may be used to endorse or promote products derived from this software
  *      without specific prior written permission.
  *
  * THIS SOFTWARE IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS "AS IS"
  * AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE
  * IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE
  * DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT HOLDER OR CONTRIBUTORS BE LIABLE
  * FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL
  * DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR
  * SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER
  * CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY,
  * OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE
  * OF THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.
  *
  ******************************************************************************
  */
#include "main.h"
#include "stm32f4xx_hal.h"
#include <stdio.h>
#include "Wdg.h"
#include "Gpio.h"
#include "Rcc.h"
#include "Rng.h"
#include "Nvic.h"
#include "sysTick.h"
#include "ExtIntr.h"
#include "Timer.h"
#include "I2c.h"
#include "Flash.h"
#include "Usart.h"
#include "Dma.h"
#include "Adc.h"

/* USER CODE BEGIN Includes */
#define blueButtonPin 0
#define greenLedPin 13
#define redLedPin 	14

/* USER CODE END Includes */

/* USER CODE BEGIN PV */
/* Private variables ---------------------------------------------------------*/

/* USER CODE END PV */

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
void printCauseOfReset(void);
extern void initialise_monitor_handles(void);

/* USER CODE BEGIN PFP */
/* Private function prototypes -----------------------------------------------*/

/* USER CODE END PFP */

int main(void)
{

  /* USER CODE BEGIN 1 */
	volatile int count;
	initialise_monitor_handles();
	#define	ARR1		125
	#define ARR2		12
	uint16_t	timerWaveForm[]= {ARR1,ARR2,ARR1,ARR2,ARR1+2};
  /* USER CODE END 1 */

  /* MCU Configuration----------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();

  /* USER CODE BEGIN 2 */

  //dmaTransmitData("okas");
 // i = dmaStreamTransferComplete(dma2 ,3);
  //i = dmaStreamTransferComplete(dma2 ,4);
  //i = dmaStreamTransferComplete(dma2 ,5);
  //i = dmaStreamTransferComplete(dma2 ,7);

/*
  //enable i2c1 event interrupt
  nvicEnableIrq(31);
  nvicSetPriority(31,8);
  //disable
  nvicDisableIrq(31);
*/

 // printf("helloWorld\n");
  enableGpioA();
  enableGpioG();
  enableGpioC();

  // gpioConfig(GpioA,blueButtonPin, GPIO_MODE_IN ,0,GPIO_NO_PULL,0);
   gpioConfig(GpioG,redLedPin, GPIO_MODE_OUT , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_LOW_SPEED);
 //  gpioConfig(GpioG,greenLedPin, GPIO_MODE_OUT , GPIO_PUSH_PULL,GPIO_PULL_DOWN,GPIO_VHIGH_SPEED);
 //  gpioConfig(GpioA,8, GPIO_MODE_AF , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_VHIGH_SPEED);

 //  gpioConfigAltFuncNum(GpioA,8,ALT_FUNC0);
  // rccSelectMco1Src(MCO_HSE_SRC);
  // rccSetMco1Prescaler(MCO_DIV_5);
   //enableDma(DMA2_DEV);
  // gpioConfig(GpioB,6, GPIO_MODE_AF , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_LOW_SPEED);
   //dmaIntiForTimer8();

 // nvicEnableIrq(80);
 // nvicSetPriority(80,4);

 // getRandomNumberByInterrupt();

//  sysTickSetReload(11250000);
//  sysTickSetReload(10);
 // sysTickPrescaledSpeed();
  //sysTickClrCounter();
 // sysTickEnable();
 // sysTickIntrEnable();

 //  nvicEnableIrq(6);
 //  nvicSetPriority(6,4);

 // sysTickDisable();
 // enableRng();
 // initTimer8();

 // InitI2c();

  //enable GPIO 0
 // risingDisable(0);
 // fallingDisable(0);
 // interMaskEnable(0);
 // risingEnable(0);

 // eventMaskEnable(0);
   //initTimer8();
  // initTimer8_OC();
   //SetTimer8C1ToOC();
   //dmaSetAddressAndSize(timerWaveForm,&(timer8->CCR1),sizeof(timerWaveForm));
   //flashEraseSector(13);
  //flashEnableProgramming(FLASH_WORD_SIZE);
  //flashWriteMessage("hello world",(char *)0x08084000);

   // dmaIntiForUsart1();
  // enableAdc();
   //initAdc();

   gpioConfig(GpioA,9, GPIO_MODE_AF , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_VHIGH_SPEED);
   gpioConfigAltFuncNum(GpioA,9,ALT_FUNC7);
   gpioConfig(GpioA,10, GPIO_MODE_AF , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_VHIGH_SPEED);
   gpioConfigAltFuncNum(GpioA,10,ALT_FUNC7);
   gpioConfig(GpioC,6, GPIO_MODE_AF , GPIO_PUSH_PULL,GPIO_NO_PULL,GPIO_VHIGH_SPEED);
   gpioConfigAltFuncNum(GpioC,6,ALT_FUNC3);

   enableWwdg();

   printCauseOfReset();
   for(int i=0;i<20;i++){

	   gpioWrite(GpioG,redLedPin,1);
	  	  HAL_Delay(50);
	  	  gpioWrite(GpioG,redLedPin,0);
	  	  HAL_Delay(50);

   }
   setDivider(DIVIDE_2);
   	  	initWwdg(30);
   	  	set(63);
while(1){
	HAL_Delay(10);
	set(28);
}
RCC_CLEAR_RESET();

   // initIwdg(2000);
  //  Idwg_reset();

   //enableUsart();
   //initUsart();
   //configBaudRate();
    //   EnableTrans();
  //     DisableReceiv();

 // Flash->SR |= FLASH_PGSERR;
 /*  flashEnableProgramming(FLASH_BYTE_SIZE);
   flashWriteMessage("hello world",(char *)0x08100000);
   flashEraseSector(12);
  if(flashEraseSector(13)==1){
//  flashEnableProgramming(FLASH_BYTE_SIZE);
  flashWriteMessage("hello world",(char *)0x08084000);
  flashDisable();
  while(1);
  }
  else{
	  while(1);
  }

*/
  // sendBitPattern(100);

  /* USER CODE END 2 */

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */
       volatile int clockSpeed = HAL_RCC_GetPCLK2Freq();
  while (1)
  {
  /* USER CODE END WHILE */
	//  forceOutCompareChannel1Low();
	 // forceOutCompareChannel1High();
	 // getDataAdc();
	 // togglemode();
	/*  gpioWrite(GpioG,redLedPin,1);
	  HAL_Delay(50);
	  gpioWrite(GpioG,redLedPin,0);
	  HAL_Delay(50);
*/
  }

}

/** System Clock Configuration
*/
void SystemClock_Config(void)
{

  RCC_OscInitTypeDef RCC_OscInitStruct;
  RCC_ClkInitTypeDef RCC_ClkInitStruct;

    /**Configure the main internal regulator output voltage
    */
  __HAL_RCC_PWR_CLK_ENABLE();

  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE1);

    /**Initializes the CPU, AHB and APB busses clocks
    */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLM = 8;
  RCC_OscInitStruct.PLL.PLLN = 360;
  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV2;
  RCC_OscInitStruct.PLL.PLLQ = 4;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    _Error_Handler(__FILE__, __LINE__);
  }

    /**Activate the Over-Drive mode
    */
  if (HAL_PWREx_EnableOverDrive() != HAL_OK)
  {
    _Error_Handler(__FILE__, __LINE__);
  }

    /**Initializes the CPU, AHB and APB busses clocks
    */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV4;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV4;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_5) != HAL_OK)
  {
    _Error_Handler(__FILE__, __LINE__);
  }

    /**Configure the Systick interrupt time
    */
  HAL_SYSTICK_Config(HAL_RCC_GetHCLKFreq()/1000);

    /**Configure the Systick
    */
  HAL_SYSTICK_CLKSourceConfig(SYSTICK_CLKSOURCE_HCLK);

  /* SysTick_IRQn interrupt configuration */
  HAL_NVIC_SetPriority(SysTick_IRQn, 0, 0);
}

/** Configure pins as
        * Analog
        * Input
        * Output
        * EVENT_OUT
        * EXTI
*/
static void MX_GPIO_Init(void)
{

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOH_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();

}

/* USER CODE BEGIN 4 */

void EXTI0_IRQHandler(void){

	int count ;
	clearPending(0);
	SET_PIN(GpioG,redLedPin);
	count++;
	RESET_PIN(GpioG,redLedPin);

}

void My_SysTick_Handler(void){
	static int ledState = 0;
	//jus ntg,but read the ctrl reg to clear countflag
	volatile int flags = Tick->CTRL;
	gpioWrite(GpioG,redLedPin,(ledState = !ledState));

}
void HASH_RNG_IRQHandler(void){
	volatile int rand = Rng->DR;
}

void wait500ms(){
	while(!(timer8->SR & 1)){

	}
	timer8->SR &=  0;
}
/* USER CODE END 4 */

void _Error_Handler(char * file, int line)
{
  while(1)
  {
  }
}

//print cause of reset
void printCauseOfReset(void){
	if(Rcc->CSR & LOW_POWER_RESET){
		printf("low power reset\n");
	}
	if(Rcc->CSR & WWDD_RESET){
			printf("window watch dog reset\n");
		}
	if(Rcc->CSR & IWDG_RESET){
				printf("independent watch dog reset\n");
			}
	if(Rcc->CSR & SFT_RESET){
					printf("software reset\n");
				}
	if(Rcc->CSR & PORR_RESET){
					printf("power on /off reset\n");
				}
	if(Rcc->CSR & PIN_RESET){
					printf("pin reset\n");
				}
	if(Rcc->CSR & BORR_RESET){
					printf("brown out reset\n");
				}

	/*else{
		printf("no reset\n");
	}*/

}

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/
